# Keil uVision project SAMR21_213_Clock.uvprojx, settings and files
target SAMR21 2.13 Minute Clock (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x18000) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: epd_clock +hex
  AfterMake: fromelf.exe --bin --output .\Objects\epd_white.bin .\Objects\epd_white.axf
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __SAMR21G18A__
  c misc: --c99 --library_type=microlib
  c include: .\App;..\SAMR21_EPD_Keil\Device;..\SAMR21_EPD_Keil\CMSIS
  asm define: __MICROLIB
  memory RVCT4: RAM 0x20000000 size 0x8000
  memory RVCT9: ROM 0x0 size 0x18000
  scatter file: .\samr21.sct
  link misc: --library_type=microlib --map --symbols
  group App
    ./App/: main.c graphics.c clock.c
  group Board driver
    ./Drivers/: epd.c
  group Startup
    ./Startup/: system_samr21.c startup_samr21.s
