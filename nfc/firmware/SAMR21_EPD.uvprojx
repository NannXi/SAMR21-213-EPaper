# Keil uVision project SAMR21_EPD.uvprojx, settings and files
target SAMR21 NFC ePaper (ARM-ADS)
  device: Cortex-M0+ ARM
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x18000) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: epd_white +hex
  AfterMake: fromelf.exe --bin --output .\Objects\epd_white.bin .\Objects\epd_white.axf
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __SAMR21G18A__
  c misc: --c99 --library_type=microlib
  c include: .\App;.\Device;.\CMSIS
  asm define: __MICROLIB
  memory RVCT4: RAM 0x20000000 size 0x8000
  memory RVCT9: ROM 0x0 size 0x18000
  scatter file: .\samr21.sct
  link misc: --library_type=microlib --map --symbols
  group App
    ./App/: main.c graphics.c protocol.c device_clock.c low_power.c
  group Board driver
    ./Drivers/: epd.c nfc.c
  group Startup
    ./Startup/: system_samr21.c startup_samr21.s
